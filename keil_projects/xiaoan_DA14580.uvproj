# Keil uVision project xiaoan_DA14580.uvproj, settings and files
target DA14580_SIMCOM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: DA14580_SIMCOM +hex
  c flags: Optim=1 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h --bss_threshold=0
  c include: .\..\src\dialog_api;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;.\..\src\plf_refip\arch;.\..\src\plf_refip\arch\compiler\rvds;.\..\src\plf_refip\arch\boot\rvds;.\..\src\plf_refip\arch\ll\rvds;.\..\src\plf_refip\driver\reg;.\..\src\modules\common\api;.\..\src\modules\dbg\api;.\..\src\modules\display\api;.\..\src\modules\gtl\api;.\..\src\modules\ke\api;.\..\src\modules\ke\src;.\..\src\modules\nvds\api;.\..\src\modules\rf\api;.\..\src\modules\rwip\api;.\..\src\ip_ble\ll\src\rwble;.\..\src\ip_ble\ll\src\controller\em;.\..\src\ip_ble\ll\src\controller\llc;.\..\src\ip_ble\ll\src\controller\lld;.\..\src\ip_ble\ll\src\controller\llm;.\..\src\plf_refip\driver\led;.\..\src\plf_refip\driver\timer;.\..\src\plf_refip\driver\syscntl;.\..\src\plf_refip\driver\emi;.\..\src\plf_refip\driver\uart;.\..\src\plf_refip\driver\flash;.\..\src\plf_refip\driver\gpio;.\..\src\ip_ble\hl\src\host\att;.\..\src\ip_ble\hl\src\host\att\attc;.\..\src\ip_ble\hl\src\host\att\attm;.\..\src\ip_ble\hl\src\host\gap;.\..\src\ip_ble\hl\src\host\gap\gapc;.\..\src\ip_ble\hl\src\host\gap\gapm;.\..\src\ip_ble\hl\src\host\att\atts;.\..\src\ip_ble\hl\src\host\gatt;.\..\src\ip_ble\hl\src\host\gatt\gattc;.\..\src\ip_ble\hl\src\host\gatt\gattm;.\..\src\ip_ble\hl\src\host\l2c\l2cc;.\..\src\ip_ble\hl\src\host\l2c\l2cm;.\..\src\ip_ble\hl\src\host\smp\smpc;.\..\src\ip_ble\hl\src\host\smp\smpm;.\..\src\ip_ble\hl\src\profiles;.\..\src\ip_ble\hl\src\profiles\accel;.\..\src\ip_ble\hl\src\profiles\bas\basc;.\..\src\ip_ble\hl\src\profiles\bas\bass;.\..\src\ip_ble\hl\src\profiles\blp;.\..\src\ip_ble\hl\src\profiles\blp\blpc;.\..\src\ip_ble\hl\src\profiles\blp\blps;.\..\src\ip_ble\hl\src\profiles\dis\disc;.\..\src\ip_ble\hl\src\profiles\dis\diss;.\..\src\ip_ble\hl\src\profiles\find\findl;.\..\src\ip_ble\hl\src\profiles\find\findt;.\..\src\ip_ble\hl\src\profiles\hogp;.\..\src\ip_ble\hl\src\profiles\hogp\hogpbh;.\..\src\ip_ble\hl\src\profiles\hogp\hogpd;.\..\src\ip_ble\hl\src\profiles\hogp\hogprh;.\..\src\ip_ble\hl\src\profiles\hrp;.\..\src\ip_ble\hl\src\profiles\hrp\hrpc;.\..\src\ip_ble\hl\src\profiles\hrp\hrps;.\..\src\ip_ble\hl\src\profiles\htp;.\..\src\ip_ble\hl\src\profiles\htp\htpc;.\..\src\ip_ble\hl\src\profiles\htp\htpt;.\..\src\ip_ble\hl\src\profiles\prox\proxm;.\..\src\ip_ble\hl\src\profiles\prox\proxr;.\..\src\ip_ble\hl\src\profiles\scpp;.\..\src\ip_ble\hl\src\profiles\scpp\scppc;.\..\src\ip_ble\hl\src\profiles\scpp\scpps;.\..\src\plf_refip\driver\intc;.\..\src\ip_ble\hl\src\rwble_hl;.\..\src\ip_ble\ll\src\hcic;.\..\src\ip_ble\hl\src\host\smp;.\..\src\modules\app\api;.\..\src\modules\gtl\src;.\..\src\ip_ble\hl\src\profiles\anp;.\..\src\ip_ble\hl\src\profiles\anp\anpc;.\..\src\ip_ble\hl\src\profiles\anp\anps;.\..\src\ip_ble\hl\src\profiles\cscp;.\..\src\ip_ble\hl\src\profiles\cscp\cscpc;.\..\src\ip_ble\hl\src\profiles\cscp\cscps;.\..\src\ip_ble\hl\src\profiles\glp;.\..\src\ip_ble\hl\src\profiles\glp\glpc;.\..\src\ip_ble\hl\src\profiles\glp\glps;.\..\src\ip_ble\hl\src\profiles\pasp;.\..\src\ip_ble\hl\src\profiles\pasp\paspc;.\..\src\ip_ble\hl\src\profiles\pasp\pasps;.\..\src\ip_ble\hl\src\profiles\rscp;.\..\src\ip_ble\hl\src\profiles\rscp\rscpc;.\..\src\ip_ble\hl\src\profiles\rscp\rscps;.\..\src\ip_ble\hl\src\profiles\tip;.\..\src\ip_ble\hl\src\profiles\tip\tipc;.\..\src\ip_ble\hl\src\profiles\tip\tips;.\..\src\modules\app\src\;.\..\src\modules\app\src\app_project\template_fh;.\..\src\plf_refip\driver\adc;.\..\src\modules\app\src\app_project\template_fh\system;.\..\src\plf_refip\driver\wkupct;.\..\src\plf_refip\driver\battery;..\src\modules\app\src\app_project\sps;..\src\modules\app\src\app_profiles\spsc;..\src\modules\app\api;..\src\ip_ble\hl\src\profiles\sps\sps_client;..\src\modules\app\src\app_utils\app_stream_queue;..\src\modules\app\src\app_project\sps\system;..\src\modules\app\src\app_project\sps\uart;..\src\ip_ble\hl\src\profiles\sps\sps_server;.\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT5: ROM 0x21000 size 0x13f00
  memory RVCT9: RAM 0x20005100 size 0x5600
  memory RVCT10: RAM 0x8000 size 0x1000
  scatter file: ..\scatterfiles\scatterfile_common.sct
  link misc: ..\misc\rom_symdef.txt  --symdefs=full_emb_sysram_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group boot
    ../src/plf_refip/arch/boot/rvds/: boot_vectors.s system_ARMCM0.c
  group obj
    ../object/: atts_task.obj atts_util.obj ch_map.obj gapm_util.obj ke_mem.obj ke_task.obj smpc.obj smpc_task.obj
  group arch
    ../src/plf_refip/arch/main/ble/: arch_main.c arch_sleep.c arch_system.c jump_table.c nmi_handler.c hardfault_handler.c
  group driver
    ../src/modules/rf/src/: rf_580.c
    ../src/modules/app/src/app_project/sps/uart/: uart_sps.c
    ../src/plf_refip/driver/gpio/: gpio.c
  group nvds
    ../src/modules/nvds/src/: nvds.c
  group gapm
    ../src/ip_ble/hl/src/host/gap/gapm/: gapm.c
  group rwble
    ../src/modules/rwip/src/: rwip.c
    ../src/ip_ble/ll/src/rwble/: rwble.c
  group periph_setup
    ../src/modules/app/src/app_project/sps/system/: periph_setup.c
  group profiles
    ../src/ip_ble/hl/src/profiles/sps/sps_client/: sps_client.c sps_client_task.c
    ../src/ip_ble/hl/src/profiles/: prf_utils.c prf_utils_128.c
  group app
    ../src/modules/app/src/: app.c app_task.c
    ./: app_user.c
    ../src/modules/app/src/app_project/sps/: app_sps_host_project.c app_sps_scheduler.c
    ../src/modules/app/src/app_profiles/spsc/: app_spsc.c app_spsc_task.c
